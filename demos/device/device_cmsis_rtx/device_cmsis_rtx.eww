<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\device_cmsis_rtx.ewp</path>
  </project>
</workspace>


