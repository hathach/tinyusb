# IAR project device_freertos.ewp, settings and files
configuration Board_EA4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; TUSB_CFG_MCU=MCU_LPC43XX; BOARD=BOARD_EA4357; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: ..\src; ..\..\..\mcu\lpc43xx\CMSIS_LPC43xx_DriverLib\inc; ..\..\..\boards; ..\..\..\tinyusb; ..\..\..\vendor\freertos; ..\..\..\vendor\freertos\freertos\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\vendor\freertos
  OBJCOPY.OOCOutputFile: device_freertos.srec
  ILINK.IlinkOutputFile: device_freertos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Board_LPCXpresso1769 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCDefines: TUSB_CFG_MCU=MCU_LPC175X_6X; BOARD=BOARD_LPCXPRESSO1769; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: ..\src; ..\..\..\mcu\lpc175x_6x\CMSIS_CORE_LPC17xx\inc; ..\..\..\mcu\lpc175x_6x\LPC17xx_DriverLib\include; ..\..\..\boards; ..\..\..\tinyusb; ..\..\..\vendor\freertos; ..\..\..\vendor\freertos\freertos\Source\include
configuration Board_NGX4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4; TUSB_CFG_MCU=MCU_LPC43XX; BOARD=BOARD_NGX4330; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ILINK.IlinkIcfFile: ..\..\..\mcu\lpc43xx\iar\lpc4330_m4_spifi.icf
configuration Board_rf1ghznode (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC11U37FBD48_401 NXP LPC11U37FBD48_401
  ICCARM.CCDefines: TUSB_CFG_MCU=MCU_LPC11UXX; BOARD=BOARD_RF1GHZNODE; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: ..\src; ..\..\..\mcu\lpc11uxx\CMSIS_CORE_LPC11Uxx\inc; ..\..\..\mcu\lpc11uxx\LPC11Uxx_DriverLib; ..\..\..\boards; ..\..\..\tinyusb; ..\..\..\vendor\freertos; ..\..\..\vendor\freertos\freertos\Source\include
configuration Board_LPCXpresso1347 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  ICCARM.CCDefines: TUSB_CFG_MCU=MCU_LPC13UXX; BOARD=BOARD_LPCXPRESSO1347; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: ..\src; ..\..\..\mcu\lpc13uxx\CMSIS_CORE_LPC13Uxx\inc; ..\..\..\mcu\lpc13uxx\LPC13Uxx_DriverLib\inc; ..\..\..\boards; ..\..\..\tinyusb; ..\..\..\vendor\freertos; ..\..\..\vendor\freertos\freertos\Source\include
configuration Board_LPCXpresso11u14 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC11U14FHI33_201 NXP LPC11U14FHI33_201
  ICCARM.CCDefines: TUSB_CFG_MCU=MCU_LPC11UXX; BOARD=BOARD_LPCXPRESSO11U14; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: as above
  group app
    ../src/: cdc_device_app.c keyboard_device_app.c main.c mouse_device_app.c msc_device_app.c msc_device_ramdisk.c msc_device_romdisk.c tusb_descriptors.c
  group boards
    ../../../boards/: board.c printf_retarget.c
    ../../../boards/embedded_artists/ea4357/: board_ea4357.c
    ../../../boards/microbuilder/: board_lpc4357usb.c board_rf1ghznode.c
    ../../../boards/lpcxpresso/: board_lpcxpresso11u14.c board_lpcxpresso1347.c board_lpcxpresso1769.c
    ../../../boards/ngx/: board_ngx4330.c
    ../../../boards/embedded_artists/oem_base_board/: pca9532.c
  group freertos
    ../../../vendor/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../vendor/freertos/: freertos_hook.c
    ../../../vendor/freertos/freertos/Source/portable/MemMang/: heap_4.c
  group freertos/CM0
    ../../../vendor/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group freertos/CM3
    ../../../vendor/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group freertos/CM4F
    ../../../vendor/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group mcu/lpc11uxx
    ../../../mcu/lpc11uxx/LPC11Uxx_DriverLib/: lpc11uxx_gpio.c lpc11uxx_uart.c
    ../../../mcu/lpc11uxx/iar/: startup_lpc11xx.s
    ../../../mcu/lpc11uxx/CMSIS_CORE_LPC11Uxx/src/: system_LPC11Uxx.c
  group mcu/lpc13uxx
    ../../../mcu/lpc13uxx/LPC13Uxx_DriverLib/src/: gpio.c uart.c
    ../../../mcu/lpc13uxx/iar/: startup_lpc13xx.s
    ../../../mcu/lpc13uxx/CMSIS_CORE_LPC13Uxx/src/: system_LPC13Uxx.c
  group mcu/lpc175x_6x
    ../../../mcu/lpc175x_6x/LPC17xx_DriverLib/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_uart.c
    ../../../mcu/lpc175x_6x/iar/: startup_LPC17xx.s
    ../../../mcu/lpc175x_6x/CMSIS_CORE_LPC17xx/src/: system_LPC17xx.c
  group mcu/lpc43xx
    ../../../mcu/lpc43xx/CMSIS_LPC43xx_DriverLib/src/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_uart.c system_LPC43xx.c
    ../../../mcu/lpc43xx/iar/: startup_LPC43xx.s
  group tinyusb
    ../../../tinyusb/: tusb.c
  group tinyusb/class
    ../../../tinyusb/class/: cdc_device.c cdc_host.c hid_device.c hid_host.c msc_device.c msc_host.c
  group tinyusb/common
    ../../../tinyusb/common/: fifo.c tusb_errors.c
  group tinyusb/device
    ../../../tinyusb/device/: dcd.c dcd_lpc175x_6x.c dcd_lpc43xx.c dcd_lpc_11uxx_13uxx.c usbd.c
  group tinyusb/hal
    ../../../tinyusb/hal/: hal_lpc11uxx.c hal_lpc13uxx.c hal_lpc175x_6x.c hal_lpc43xx.c
  group tinyusb/host
    ../../../tinyusb/host/ehci/: ehci.c
    ../../../tinyusb/host/: hcd.c hub.c usbh.c
    ../../../tinyusb/host/ohci/: ohci.c
  group tinyusb/osal
    ../../../tinyusb/osal/: osal_none.c
