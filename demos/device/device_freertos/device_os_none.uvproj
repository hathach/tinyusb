# Keil uVision project device_os_none.uvproj, settings and files
target Board EA4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: device_os_none
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4 TUSB_CFG_MCU=MCU_LPC43XX BOARD=BOARD_EA4357 TUSB_CFG_OS=TUSB_OS_FREERTOS TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  c misc: --gnu --c99
  c include: ..\src;..\..\..\mcu\lpc43xx\CMSIS_LPC43xx_DriverLib\inc;..\..\..\boards;..\..\..\tinyusb;..\..\..\vendor\fatfs;..\..\..\vendor\freertos;..\..\..\vendor\freertos\freertos\Source\include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group app
    ../src/: main.c tusb_descriptors.c cdc_device_app.c keyboard_device_app.c mouse_device_app.c msc_device_app.c msc_device_ramdisk.c msc_device_romdisk.c
  group tinyusb
    ../../../tinyusb/: tusb.c
    ../../../tinyusb/osal/: osal_none.c
    ../../../tinyusb/host/: hcd.c hub.c usbh.c
    ../../../tinyusb/host/ehci/: ehci.c
    ../../../tinyusb/hal/: hal_lpc11uxx.c hal_lpc13uxx.c hal_lpc43xx.c hal_lpc175x_6x.c
    ../../../tinyusb/common/: tusb_errors.c fifo.c
    ../../../tinyusb/class/: cdc_host.c hid_host.c msc_host.c cdc_device.c hid_device.c msc_device.c
    ../../../tinyusb/device/: dcd.c dcd_lpc_11uxx_13uxx.c dcd_lpc43xx.c dcd_lpc175x_6x.c usbd.c
  group boards
    ../../../boards/: board.c printf_retarget.c
    ../../../boards/embedded_artists/ea4357/: board_ea4357.c
    ../../../boards/embedded_artists/oem_base_board/: pca9532.c
    ../../../boards/ngx/: board_ngx4330.c
    ../../../boards/microbuilder/: board_lpc4357usb.c board_rf1ghznode.c
    ../../../boards/lpcxpresso/: board_lpcxpresso1769.c board_lpcxpresso1347.c board_lpcxpresso11u14.c
    ../../../boards/keil/: board_mcb4300.c
  group lpc11uxx
    ../../../mcu/lpc11uxx/CMSIS_CORE_LPC11Uxx/src/: system_LPC11Uxx.c
    ../../../mcu/lpc11uxx/LPC11Uxx_DriverLib/: lpc11uxx_gpio.c lpc11uxx_uart.c
    ../../../mcu/lpc11uxx/keil/: startup_LPC11Uxx.s
  group lpc13uxx
    ../../../mcu/lpc13uxx/keil/: startup_LPC13Uxx.s
    ../../../mcu/lpc13uxx/CMSIS_CORE_LPC13Uxx/src/: system_LPC13Uxx.c
    ../../../mcu/lpc13uxx/LPC13Uxx_DriverLib/src/: gpio.c uart.c
  group lpc175x_6x
    ../../../mcu/lpc175x_6x/CMSIS_CORE_LPC17xx/src/: system_LPC17xx.c
    ../../../mcu/lpc175x_6x/LPC17xx_DriverLib/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_uart.c
    ../../../mcu/lpc175x_6x/keil/: startup_LPC17xx.s
  group lpc43xx
    ../../../mcu/lpc43xx/CMSIS_LPC43xx_DriverLib/src/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_nvic.c lpc43xx_scu.c lpc43xx_uart.c system_LPC43xx.c
    ../../../mcu/lpc43xx/keil/: startup_LPC43xx.s
  group freertos
    ../../../vendor/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../vendor/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port_cm0.c
    ../../../vendor/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port_cm3.c
    ../../../vendor/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port_cm4f.c
    ../../../vendor/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../vendor/freertos/freertos/Source/portable/MemMang/: heap_4.c
target Board LPC4357USB (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: device_os_none
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4 TUSB_CFG_MCU=MCU_LPC43XX BOARD=BOARD_LPC4357USB TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: ..\src;..\..\..\mcu\lpc43xx\CMSIS_LPC43xx_DriverLib\inc;..\..\..\boards;..\..\..\tinyusb;..\..\..\vendor\fatfs
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Board LPCXpresso1347 (ARM-ADS)
  device: LPC1347 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: device_os_none
  c flags: Optim=1
  c define: TUSB_CFG_MCU=MCU_LPC13UXX BOARD=BOARD_LPCXPRESSO1347 TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: ..\..\..\mcu\lpc13uxx\CMSIS_CORE_LPC13Uxx\inc;..\..\..\mcu\lpc13uxx\LPC13Uxx_DriverLib\inc;..\src;..\..\..\boards;..\..\..\tinyusb
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: ..\..\..\mcu\lpc13uxx\keil\lpc13uxx.sct
target Board LPCXpresso1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: device_os_none
  c flags: Optim=1
  c define: TUSB_CFG_MCU=MCU_LPC175X_6X BOARD=BOARD_LPCXPRESSO1769 TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: ..\..\..\mcu\lpc175x_6x\CMSIS_CORE_LPC17xx\inc;..\..\..\mcu\lpc175x_6x\LPC17xx_DriverLib\include;..\src;..\..\..\boards;..\..\..\tinyusb
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Board rf1ghznode (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: device_os_none
  c flags: Optim=1
  c define: TUSB_CFG_MCU=MCU_LPC11UXX BOARD=BOARD_RF1GHZNODE TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: ..\..\..\mcu\lpc11uxx\CMSIS_CORE_LPC11Uxx\inc;..\..\..\mcu\lpc11uxx\LPC11Uxx_DriverLib;..\src;..\..\..\boards;..\..\..\tinyusb
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: ..\..\..\mcu\lpc11uxx\keil\lpc11uxx.sct
target Board NGX4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: device_os_none
  c flags: Optim=1
  c define: CORE_M4 TUSB_CFG_MCU=MCU_LPC43XX BOARD=BOARD_NGX4330 TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Board LPCXpresso11u14 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: device_os_none
  c flags: Optim=1
  c define: TUSB_CFG_MCU=MCU_LPC11UXX BOARD=BOARD_LPCXPRESSO11U14 TUSB_CFG_OS=TUSB_OS_NONE
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: ..\..\..\mcu\lpc11uxx\keil\lpc11uxx.sct
