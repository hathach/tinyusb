# IAR project host_freertos.ewp, settings and files
configuration Board EA4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; TUSB_CFG_MCU=MCU_LPC43XX; BOARD=BOARD_EA4357; TUSB_CFG_OS=TUSB_OS_FREERTOS; TUSB_CFG_OS_TASK_PRIO=configMAX_PRIORITIES-5
  ICCARM.CCIncludePath2: ..\src; ..\..\bsp\lpc43xx\CMSIS_LPC43xx_DriverLib\inc; ..\..\bsp; ..\..\..\tinyusb; ..\..\..\vendor\fatfs; ..\..\..\vendor\freertos; ..\..\..\vendor\freertos\freertos\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: host_freertos.srec
  ILINK.IlinkOutputFile: host_freertos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Board LPCXpresso1769 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCDefines: TUSB_CFG_MCU=MCU_LPC175X_6X; BOARD=BOARD_LPCXPRESSO1769; TUSB_CFG_OS=TUSB_OS_NONE
  ICCARM.CCIncludePath2: ..\src; ..\..\bsp\lpc175x_6x\CMSISv2p00_LPC17xx\inc; ..\..\bsp\lpc175x_6x\LPC17xx_DriverLib\include; ..\..\bsp; ..\..\..\tinyusb; ..\..\..\vendor\fatfs
configuration Board NGX4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4; TUSB_CFG_MCU=MCU_LPC43XX; BOARD=BOARD_NGX4330; TUSB_CFG_OS=TUSB_OS_NONE
  ICCARM.CCIncludePath2: ..\src; ..\..\bsp\lpc43xx\CMSIS_LPC43xx_DriverLib\inc; ..\..\bsp; ..\..\..\tinyusb; ..\..\..\vendor\fatfs
  group app
    ../src/: cdc_serial_app.c cli.c keyboard_app.c main.c mouse_app.c msc_app.c
  group bsp/boards
    ../../bsp/boards/: board.c printf_retarget.c
    ../../bsp/boards/embedded_artists/ea4357/: board_ea4357.c
    ../../bsp/boards/microbuilder/: board_lpc4357usb.c
    ../../bsp/boards/lpcxpresso/: board_lpcxpresso1769.c
    ../../bsp/boards/ngx/: board_ngx4330.c
    ../../bsp/boards/embedded_artists/oem_base_board/: pca9532.c
  group bsp/lpc175x_6x
    ../../bsp/lpc175x_6x/CMSISv2p00_LPC17xx/src/: core_cm3.c system_LPC17xx.c
    ../../bsp/lpc175x_6x/LPC17xx_DriverLib/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_uart.c
    ../../bsp/lpc175x_6x/startup_iar/: startup_LPC17xx.s
  group bsp/lpc43xx
    ../../bsp/lpc43xx/CMSIS_LPC43xx_DriverLib/src/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_uart.c system_LPC43xx.c
    ../../bsp/lpc43xx/startup_iar/: startup_LPC43xx.s
  group fatfs
    ../../../vendor/fatfs/: ccsbcs.c diskio.c ff.c
  group freertos
    ../../../vendor/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../vendor/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../vendor/freertos/freertos/Source/portable/MemMang/: heap_4.c
  group freertos/CM4F
    ../../../vendor/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group tinyusb
    ../../../tinyusb/: tusb.c
  group tinyusb/class
    ../../../tinyusb/class/: cdc_host.c cdc_rndis_host.c hid_host.c msc_host.c
  group tinyusb/common
    ../../../tinyusb/common/: errors.c
  group tinyusb/hal
    ../../../tinyusb/hal/: hal_lpc11uxx.c hal_lpc13uxx.c hal_lpc175x_6x.c hal_lpc43xx.c
  group tinyusb/host
    ../../../tinyusb/host/ehci/: ehci.c
    ../../../tinyusb/host/: hcd.c hub.c usbh.c
    ../../../tinyusb/host/ohci/: ohci.c
  group tinyusb/osal
    ../../../tinyusb/osal/: osal_none.c
