<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\host_freertos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>host_freertos</project>
        <configuration>Board EA4357</configuration>
      </member>
      <member>
        <project>host_freertos</project>
        <configuration>Board LPCXpresso1769</configuration>
      </member>
      <member>
        <project>host_freertos</project>
        <configuration>Board NGX4330</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


