# Keil uVision project host.uvproj, settings and files
target LPC4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: host
  c flags: Optim=1
  c define: MCU=MCU_LPC43XX BOARD=BOARD_EA4357 CORE_M4
  c misc: --gnu --c99
  c include: C:/Users/hathach/Dropbox/tinyusb/workspace/CMSISv2p10_LPC43xx_DriverLib/inc;C:/Users/hathach/Dropbox/tinyusb/workspace/tinyusb/demos/bsp;C:/Users/hathach/Dropbox/tinyusb/workspace/tinyusb/tinyusb;..\host
  asm include: C:/Users/hathach/Dropbox/tinyusb/workspace/CMSISv2p10_LPC43xx_DriverLib/inc;C:/Users/hathach/Dropbox/tinyusb/workspace/tinyusb/demos/bsp;C:/Users/hathach/Dropbox/tinyusb/workspace/tinyusb/tinyusb
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group bsp_boards
    ../bsp/boards/: board.c board_at86rf2xx.c board_ea4357.c board_lpcxpresso1347.c board_ngx4330.c printf_retarget.c
  group host
    ./: main.c keyboard_app.c
  group tinyusb
    ../../tinyusb/: tusb.c
  group tinyusb_class
    ../../tinyusb/class/: hid_host.c
  group tinyusb_common
    ../../tinyusb/common/: errors.c fifo.c
  group tinyusb_hal
    ../../tinyusb/hal/: hal_lpc11uxx.c hal_lpc13uxx.c hal_lpc43xx.c
  group tinyusb_host
    ../../tinyusb/host/: hcd.c usbh.c
  group tinyusb_host_ehci
    ../../tinyusb/host/ehci/: ehci.c
  group tinyusb_osal
    ../../tinyusb/osal/: osal_none.c
  group Startup
    ../bsp/lpc43xx/startup_keil/: startup_LPC43xx_arm.s
