# IAR project host_os_none.ewp, settings and files
configuration Board EA4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; TUSB_CFG_MCU=MCU_LPC43XX; BOARD=BOARD_EA4357; TUSB_CFG_OS=TUSB_OS_NONE
  ICCARM.CCIncludePath2: ..\src; ..\..\bsp\lpc43xx\CMSIS_LPC43xx_DriverLib\inc; ..\..\bsp; ..\..\..\tinyusb; ..\..\..\vendor\fatfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: host_os_none.srec
  ILINK.IlinkOutputFile: host_os_none.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../src/: cdc_serial_app.c cli.c keyboard_app.c main.c mouse_app.c msc_app.c rndis_app.c
  group bsp/boards
    ../../bsp/boards/: board.c printf_retarget.c
    ../../bsp/boards/embedded_artists/ea4357/: board_ea4357.c
    ../../bsp/boards/microbuilder/: board_lpc4357usb.c
    ../../bsp/boards/ngx/: board_ngx4330.c
    ../../bsp/boards/embedded_artists/oem_base_board/: pca9532.c
  group bsp/lpc43xx
    ../../bsp/lpc43xx/CMSIS_LPC43xx_DriverLib/src/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_uart.c system_LPC43xx.c
    ../../bsp/lpc43xx/startup_iar/: startup_LPC43xx.s
  group fatfs
    ../../../vendor/fatfs/: ccsbcs.c diskio.c ff.c
  group tinyusb
    ../../../tinyusb/: tusb.c
  group tinyusb/class
    ../../../tinyusb/class/: cdc_host.c cdc_rndis_host.c hid_host.c msc_host.c
  group tinyusb/common
    ../../../tinyusb/common/: errors.c
  group tinyusb/hal
    ../../../tinyusb/hal/: hal_lpc11uxx.c hal_lpc13uxx.c hal_lpc175x_6x.c hal_lpc43xx.c
  group tinyusb/host
    ../../../tinyusb/host/: hcd.c hub.c usbh.c
  group tinyusb/host/ehci
    ../../../tinyusb/host/ehci/: ehci.c
  group tinyusb/osal
    ../../../tinyusb/osal/: osal_none.c
