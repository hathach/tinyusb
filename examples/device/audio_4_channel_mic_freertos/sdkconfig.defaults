## examples/device/audio_4_channel_mic_freertos/sdkconfig.defaults
```kconfig
CONFIG_IDF_CMAKE=y
CONFIG_FREERTOS_HZ=1000
CONFIG_FREERTOS_SUPPORT_STATIC_ALLOCATION=y
```
