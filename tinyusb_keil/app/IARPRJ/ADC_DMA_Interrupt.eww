<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\ADC_DMA_Interrupt.ewp</path>
	</project>
	<batchBuild />
</workspace>
