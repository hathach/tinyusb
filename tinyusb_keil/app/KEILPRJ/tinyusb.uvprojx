# Keil uVision project tinyusb.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F327x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1296 --diag_suppress=111  --diag_suppress=550  --diag_suppress=3135
  c include: ..\..\Device\MM32F327x\Include;..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\ADC;..\USER;..\USER\src;..\tinyusb\class\cdc;..\tinyusb\common;..\tinyusb\device;..\tinyusb\osal;..\tinyusb\class\msc;..\tinyusb;..\tinyusb\class\cdc;..\..\Device\MM32F327x\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group HARDWARE
    ../HARDWARE/ADC/: adcx.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c msc_disk.c usb_descriptors.c
  group Tiny_usb
    ../tinyusb/class/msc/: msc_device.c
    ../tinyusb/class/cdc/: cdc_device.c
    ../tinyusb/common/: tusb_fifo.c
    ../tinyusb/device/: usbd.c usbd_control.c
    ../tinyusb/: tusb.c
  group usb_drvice
    ../usb_drvice/: dcd_mm32f327x_otg.c
  group HAL_Lib
    ../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
