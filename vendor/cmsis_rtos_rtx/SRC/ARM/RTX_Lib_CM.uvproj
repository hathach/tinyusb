# Keil uVision project RTX_Lib_CM.uvproj, settings and files
target CM0_LE (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM0_LE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM0_LE\RTX_CM0.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M0 __CMSIS_RTOS
  asm define: __CMSIS_RTOS
  group Kernel
    ../: rt_CMSIS.c rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c rt_Memory.c
  group HAL
    ./: SVC_Table.s HAL_CM0.c HAL_CM3.c HAL_CM4.c
    ../: HAL_CM.c
target CM0_BE (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: RTX_CM0_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM0_BE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM0_BE\RTX_CM0_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M0 __CMSIS_RTOS
  asm define: __CMSIS_RTOS
target CM3_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_LE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM3_LE\RTX_CM3.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
target CM3_BE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: RTX_CM3_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_BE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM3_BE\RTX_CM3_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
target CM3_LE_IFX (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3_IFX (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_LE_IFX\BuildLib.scr
  AfterMake: cmd.exe /C copy CM3_LE_IFX\RTX_CM3_IFX.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
target CM3X_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3X (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3X_LE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM3X_LE\RTX_CM3X.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG NO_EXCLUSIVE_ACCESS
  asm define: __CMSIS_RTOS
target CM4F_LE (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_LE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM4F_LE\RTX_CM4.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
target CM4F_BE (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_BE\BuildLib.scr
  AfterMake: cmd.exe /C copy CM4F_BE\RTX_CM4_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
target CM4F_LE_IFX (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_IFX (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_LE_IFX\BuildLib.scr
  AfterMake: cmd.exe /C copy CM4F_LE_IFX\RTX_CM4_IFX.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  asm define: __CMSIS_RTOS
